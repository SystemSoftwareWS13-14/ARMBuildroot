## buildroot-2013.08.1/package/show_uptime/Config.in
```kconfig
config BR2_PACKAGE_SHOW_UPTIME
	bool "show_uptime"
	help
	  Small program which prints the uptime.
```
